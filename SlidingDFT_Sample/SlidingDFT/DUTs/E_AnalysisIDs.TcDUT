TYPE E_AnalysisIDs :
(
	(* analysis chain *)
	eID_SourceFFT := 1,
	eID_SourceSDFT,
	eID_FFT,
	eID_SDFT,
	eID_SinkFFT,
	eID_SinkSDFT
	
) UDINT;
END_TYPE
